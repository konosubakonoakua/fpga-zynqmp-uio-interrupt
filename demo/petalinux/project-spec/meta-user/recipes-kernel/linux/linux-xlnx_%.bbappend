SRC_URI += "file://user_2025-05-06-02-27-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

